<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SampleSwitch</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>SampleSwitch</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


