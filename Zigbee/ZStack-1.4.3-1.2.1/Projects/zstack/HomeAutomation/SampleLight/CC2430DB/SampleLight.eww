<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SampleLight</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>SampleLight</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


